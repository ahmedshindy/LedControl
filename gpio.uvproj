# Keil uVision project gpio.uvproj, settings and files
target TivaC_gpio (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: LedControl
  c flags: Optim=1
  c include: ..\MyProjects_ws
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./: startup_TM4C123.s
  group Src
    ./: main.c
  group Mcal
    ./: Dio.c Port.c
